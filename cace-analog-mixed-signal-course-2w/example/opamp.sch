v {xschem version=3.1.0 file_version=1.2
* Schematic of a basic 2-stage opamp
.subckt opamp IN+ IN- OUT VDD VSS
...
.ends
}
